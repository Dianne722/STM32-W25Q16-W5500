# Keil uVision project C8t6_W5500.uvprojx, settings and files
target C8t6_W5500 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: C8t6_W5500 +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./User;./User/ioLibrary_Driver/Application/loopback;./User/ioLibrary_Driver/Ethernet/W5500;./User/ioLibrary_Driver/Ethernet;./User/ioLibrary_Driver/Internet/DHCP;./User/ioLibrary_Driver/Internet/TFTP;./User/ioLibrary_Driver/Internet/DNS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x8006000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ETH
    ./User/ioLibrary_Driver/Application/loopback/: loopback.c
    ./User/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ./User/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ./User/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ./User/ioLibrary_Driver/Internet/DNS/: dns.c
  group User
    ./User/: user_main.c wiz_interface.c wiz_platform.c do_dns.c httpclient.c Bootloader.c
software components: CMSIS:CORE 4.3.0
